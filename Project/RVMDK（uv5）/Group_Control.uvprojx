# Keil uVision project Group_Control.uvprojx, settings and files
target Fire_FreeRTOS (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Fire_FreeRTOS +hex
  c flags: Optim=3 uC99=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\led;..\..\FreeRTOS\include;..\..\FreeRTOS\port\RVDS\ARM_CM3;..\..\User\GeneralTim;..\..\HardWare\key;..\..\HardWare\led;..\..\HardWare\uart;..\..\HardWare\Enc;..\..\HardWare\PWM;..\..\HardWare\Motor;..\..\HardWare\PID;..\..\HardWare\MPU9250\eMPL;..\..\HardWare\MPU9250;..\..\HardWare\font;..\..\HardWare\lcd;..\..\HardWare\flash;..\..\HardWare\OLED;..\..\HardWare\Serial;..\..\HardWare\press;..\..\HardWare\Init;..\..\HardWare\Control;..\..\HardWare\MPU6050;..\..\HardWare\MPU6050\SYSTEM\delay;..\..\HardWare\MPU6050\SYSTEM\sys;..\..\HardWare\MPU6050\SYSTEM\usart;..\..\HardWare\MPU6050\eMPL;..\..\HardWare\MPU6050\SYSTEM\usart;..\..\HardWare\FashionStarServo\fashion_star_uart_servo;..\..\HardWare\FashionStarServo\ring_buffer;..\..\HardWare\FashionStarServo\sys_tick;..\..\HardWare\FashionStarServo;..\..\HardWare\uart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h FreeRTOSConfig.h
  group FreeRTOS/src
    ../../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../../FreeRTOS/port/MemMang/: heap_4.c
    ../../FreeRTOS/port/RVDS/ARM_CM3/: port.c
  group FashinoServo
    ../../HardWare/FashionStarServo/sys_tick/: sys_tick.c
    ../../HardWare/FashionStarServo/ring_buffer/: ring_buffer.c
    ../../HardWare/FashionStarServo/fashion_star_uart_servo/: fashion_star_uart_servo.c
  group HardWare
    ../../HardWare/key/: bsp_key.c
    ../../HardWare/led/: bsp_led.c
    ../../HardWare/uart/: bsp_usart.c
    ../../HardWare/PWM/: bsp_pwm.c
    ../../HardWare/Motor/: bsp_Motor.c
    ../../HardWare/Enc/: bsp_Enc.c
    ../../HardWare/Serial/: bsp_Serial.c
    ../../HardWare/OLED/: oled.c
    ../../HardWare/Init/: Init.c
    ../../HardWare/PID/: PID.c
    ../../HardWare/Control/: Control.c
  group MPU
    ../../HardWare/MPU6050/: mpu6050.c mpuiic.c
    ../../HardWare/MPU6050/SYSTEM/delay/: delay.c
    ../../HardWare/MPU6050/SYSTEM/sys/: sys.c
    ../../HardWare/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../../HardWare/MPU6050/SYSTEM/usart/: usart.c
  group DOC
    ../../Doc/: readme.txt
